## firmware/transmitter-multi-core/sdkconfig.defaults
```kconfig
CONFIG_ESP_COREDUMP_ENABLE_TO_FLASH=n
CONFIG_ESP_COREDUMP_ENABLE_TO_UART=n
CONFIG_ESP_COREDUMP_ENABLE_TO_HOST=n
```
